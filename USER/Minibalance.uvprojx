# Keil uVision project Minibalance.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Minibalance +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\HARDWARE\MOTOR;..\BALANCE\CONTROL;..\HARDWARE\ENCODER;..\BALANCE\CONTROL;..\BALANCE\DataScope_DP;..\BALANCE\show;..\BALANCE\controls;..\HARDWARE\EXTI;..\HARDWARE\MODBUS;..\HARDWARE\MODBUSCRC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group USER
    ./: Minibalance.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: LED.C
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/MODBUS/: modbus.c modbus_uart.c
    ../HARDWARE/MODBUSCRC/: ModbusCRC.c
  group BALANCE
    ../BALANCE/CONTROL/: control.c
    ../BALANCE/show/: show.c
    ../HARDWARE/DataScope_DP/: DataScope_DP.C
software components: CMSIS:CORE 5.4.0
